## hw/s1c33/Kconfig
```kconfig
# SPDX-License-Identifier: GPL-2.0-or-later

config BBK9288S
    bool
    default y
    depends on S1C33
```
